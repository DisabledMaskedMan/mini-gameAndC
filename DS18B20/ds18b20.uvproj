# Keil uVision project ds18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h LCD1602.c LCD1602.h AT24C02.c AT24C02.h I2C.c I2C.h OneWire.c DS18B20.c key.c key.h Timer0.c Timer0.h
