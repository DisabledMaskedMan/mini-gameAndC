# Keil uVision project miaobiao.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: miaobiao +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c I2C.c AT24C02.c AT24C02.h I2C.h delay.c delay.h Nixie.c Nixie.h timer0.c timer0.h key.c key.h
