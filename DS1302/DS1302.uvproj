# Keil uVision project DS1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS1302.c delay.c key.c LCD1602.c timer0.c key.h LCD1602.h timer0.h DS1302.h delay.h
